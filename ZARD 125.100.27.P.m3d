# KOMPAS-3D part (ZARD 125.100.27.P.m3d)

Model tree:
1. Операция без истории:1
